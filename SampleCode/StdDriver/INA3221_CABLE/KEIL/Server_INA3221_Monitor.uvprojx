# Keil uVision project Server_INA3221_Monitor.uvprojx, settings and files
target Server_INA3221_Monitor (6220000::V6.22::ARMCLANG)
  device: M251ZD2AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: APROM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: .\FILESUM .\obj\@L.bin .\obj\@L_SUM.bin"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc;..\Flash;..\I2C;..\Monitor;..\EEPROM;..\..\INA3221_CABLE;..\NSP23
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\APROM.SCT
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler --pad=0xFF
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
    ../: AP_STARTUP_M251.C
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c fmc.c gpio.c timer.c i2c.c usci_i2c.c uart.c
  group Flash
    ../EEPROM/: eeprom_sim.c eeprom_test.c
  group I2C
    ../I2C/: I2C_Control.c
  group Monitor
    ../Monitor/: Monitor_Control.c
  group NSP23
    ../NSP23/: NSP_DRV.C
